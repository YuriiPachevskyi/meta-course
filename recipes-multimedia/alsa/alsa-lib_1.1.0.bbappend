FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-Setup-USB-sound-card-as-a-default-one.patch \
 "