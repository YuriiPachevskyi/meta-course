LICENSE = "CLOSED"

inherit packagegroup

RDEPENDS_${PN} = "\
    openssh-sftp-server \
    rpi-config \
"
