RDEPENDS_jack-dev_remove = "${PN} (= ${EXTENDPKGV})"
