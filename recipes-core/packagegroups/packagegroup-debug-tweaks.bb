LICENSE = "CLOSED"

inherit packagegroup

RDEPENDS_${PN} = " \
    mc \
"
