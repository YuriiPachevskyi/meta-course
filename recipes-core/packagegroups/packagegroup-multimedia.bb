LICENSE = "CLOSED"

inherit packagegroup

RDEPENDS_${PN} = " \
    alsa-lib \
    alsa-utils \
    gstreamer1.0-plugins-base \
"
