FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-Configure-RPI-to-use-USB-audio-sink-as-a-default.patch \
    file://0001-audio-Add-support-of-stereo-headsets.patch \
 "
